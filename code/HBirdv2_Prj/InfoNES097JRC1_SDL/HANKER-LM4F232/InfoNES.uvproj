# Keil uVision project InfoNES.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM4F232H5QC Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: InfoNES
  c flags: Optim=1 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x800000
  group ASM
    ./: Startup.s
  group main
    ./: InfoNES_system.c main.c
  group InfoNES
    ../: InfoNES.cpp InfoNES_Mapper.cpp InfoNES_pAPU.cpp K6502.cpp
